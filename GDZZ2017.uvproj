# Keil uVision project GDZZ2017.uvproj, settings and files
target GDZZ (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: GDZZ2017
  c flags: Optim=1 uC99=1 wLevel=2
  c define: MK60D10
  c include: .\Libraries\devices\inc;.\Libraries\drivers\inc;.\Libraries\startup\CoreSupport;.\Libraries\startup\DeviceSupport;.\User\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group startup
    ./Libraries/startup/DeviceSupport/: startup_MK60D10.s system_MK60D10.c
  group drivers
    ./Libraries/drivers/src/: common.c gpio.c ftm.c pit.c uart.c lptmr.c
  group devices
    ./Libraries/devices/src/: Motor.c Encoder.c SteerActuator.c
  group user
    ./User/src/: Main.c MainProc.c ImgProc.c BorderSearch.c MathProp.c PatternMatch.c Ring.c CrossRoad.c Curve.c Barrier.c SpeedControl.c DirectionControl.c DataComm.c DoubleCar.c ModeSwitch.c
    ./User/inc/: PinMap.h Param.h TypeDef.h Config.h
